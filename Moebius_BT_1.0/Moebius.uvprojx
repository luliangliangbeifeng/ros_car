# Keil uVision project Moebius.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Moebius +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\User;.\Libraries\STM32F10x_StdPeriph_Driver\src;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\CMSIS;.\Public;.\HardWare\KEY;.\HardWare\LED;.\HardWare\BlueTooth;.\HardWare\OLED;.\HardWare\ENCODER;.\HardWare\ADC;.\HardWare\BALANCE\CONTROL;.\HardWare\BALANCE\DataScope_DP;.\HardWare\BALANCE\DMP;.\HardWare\BALANCE\filter;.\HardWare\BALANCE\MPU6050;.\HardWare\BALANCE\show;.\HardWare\IIC;.\HardWare\EXTI;.\HardWare\MOTOR;.\HardWare\PS2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ./User/: Moebius.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_dma.c
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f10x.c core_cm3.c
  group HardWare
    ./HardWare/LED/: LED.C
    ./HardWare/KEY/: key.c
    ./HardWare/MOTOR/: motor.c
    ./HardWare/ENCODER/: encoder.c
    ./HardWare/BlueTooth/: BlueTooth.c
    ./HardWare/OLED/: oled.c
    ./HardWare/ADC/: adc.c
    ./HardWare/IIC/: IOI2C.c
    ./HardWare/BALANCE/MPU6050/: MPU6050.c
    ./HardWare/BALANCE/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ./HardWare/BALANCE/filter/: filter.c
    ./HardWare/BALANCE/show/: show.c
    ./HardWare/BALANCE/CONTROL/: control.c
    ./HardWare/EXTI/: exti.c
    ./HardWare/PS2/: pstwo.c
  group Public
    ./Public/: Sys.c Systick.c Time.c USART.c Sys.h
    ./User/: define.h
